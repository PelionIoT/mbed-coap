# IAR project atmel_rfr2_libNsdl.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-5s-ec_mul-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: VERSION="(shell git describe --tags --long --dirty --always)"
  ICCAVR.newCCIncludePaths: ..\src\include; ..\..\..\libService\include; ..\..\include; ..\..\libCoap\src\include
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: VERSION="(shell git describe --tags --long --dirty --always)"; NDEBUG
  ICCAVR.CCOptLevel: 3
  group (top)
    ../src/: sn_grs.c sn_nsdl.c
