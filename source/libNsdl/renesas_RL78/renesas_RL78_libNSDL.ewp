# IAR project renesas_RL78_libNSDL.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F101GG RL78 - R5F101GG
  General.GenCodeModel: 1
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: REG_TEMPLATE
  ICCRL78.CCIncludePath2: ..\src\Include; ..\..\libCoap\src\include; ..\..\..\libService\include
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkrl78_2.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78, debug)
  as the first configuration, except:
  group (top)
    ../src/: sn_grs.c sn_nsdl.c
