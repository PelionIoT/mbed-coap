# IAR project renesas_RL78_libCoap.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F101GG RL78 - R5F101GG
  General.GenCodeModel: 1
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: REAL_EMBEDDED
  ICCRL78.CCIncludePath2: ..\src\include; ..\..\..\libService\include; ..\src\x86_include
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78, debug)
  as the first configuration, except:
  group (top)
    ../src/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
