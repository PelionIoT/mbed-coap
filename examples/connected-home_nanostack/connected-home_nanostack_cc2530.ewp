# IAR project connected-home_nanostack_cc2530.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: CC2530; SOCKET_CB; NOT_USE_NSP_ADDRESS
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\libCoap\src\include; ..\..\NanoStack\cc2530_include; ..\..\libEdtls\src\include
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../libCoap/cc2530_iar/: cc2530_libCoap.r51
    ./: hal_sleep.c main.c ns_debug.c uart_sn.c
    ../../NanoStack/: NanoStack_Library_CC2530_fix.lib
