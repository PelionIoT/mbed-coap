# IAR project connected-home_nanostack_msp_430.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlff.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 1024
  General.GHeapSize2: 2000
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MSP430; SOCKET_CB; NOT_USE_NSP_ADDRESS
  ICC430.newCCIncludePaths: ..\..\libCoap\src\include; ..\..\NanoStack\MSP430_include
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
    ../../libCoap/msp430_iar/: msp_430_libCoap.r43
    ../../NanoStack/: NanoMesh106_NanoStack202-14432.lib
