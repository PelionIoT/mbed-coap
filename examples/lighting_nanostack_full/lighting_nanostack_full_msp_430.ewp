# IAR project lighting_nanostack_full_msp_430.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlff.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 2048
  General.GHeapSize2: 4400
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MSP430; USE_NSP_ADDRESS
  ICC430.newCCIncludePaths: ..\..\libCoap\src\include; ..\..\libNsdl\src\include; ..\..\..\NanoStack-2.x\Lib_Applications\Lib\include; ..\..\..\NanoStack-2.x\Lib_Applications\Lib\include\MSP430
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
    ../../libCoap/msp430_iar/Debug/Exe/: msp_430_libCoap.r43
    ../../libNsdl/msp430_iar/Debug/Exe/: msp_430_libNsdl.r43
    ../../../../NanoMesh-1.0.6/Platforms/MSP430_CC1101_TRxEB/NanoStack 2.0 Node/NanoStack20LibraryModel/: NanoMesh106_NanoStack202-14432.lib
