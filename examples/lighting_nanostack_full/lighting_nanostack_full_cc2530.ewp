# IAR project lighting_nanostack_full_cc2530.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: SOCKET_CB; CC2530; NOT_USE_NSP_ADDRESS
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\libService\include; ..\..\libCoap\src\include; ..\..\libNsdl\src\Include; ..\..\NanoStack\cc2530_include
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../libCoap/cc2530_iar/: cc2530_libCoap.r51
    ../../libNsdl/cc2530/: cc2530_libNsdl.r51
    ./: hal_sleep.c main.c ns_debug.c uart_sn.c
    ../../NanoStack/: NanoStack_Library_CC2530_fix.lib
