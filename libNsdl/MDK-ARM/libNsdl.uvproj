# Keil uVision project libNsdl.uvproj, settings and files
target CortexM3 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: libNsdlCortexM3 (library)
  c flags: Optim=1
  c misc: --c99
  c include: ..\src\Include;..\..\..\libService\include;..\..\libCoap\src\include
  group src
    ../src/: sn_grs.c sn_nsdl.c
