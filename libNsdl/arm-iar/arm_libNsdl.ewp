# IAR project arm_libNsdl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xF ST STM32F103xF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: REG_TEMPLATE
  ICCARM.CCIncludePath2: ..\src\Include; ..\..\libCoap\src\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: arm_libNsdl.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: sn_grs.c sn_linked_list.c sn_nsdl.c
