# Keil uVision project arm_keil_libNsdl.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: libNsdl (library)
  c flags: Optim=1
  c define: TARGET_LPC1768,  TARGET_M3,  TARGET_NXP,  TARGET_LPC176X,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,
  c misc: --c99
  c include: ..\..\..\libService\libService;..\..\libCoap\src\include;..\..\libNsdl\src\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  link misc: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/sys.o
                 
                mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/cmsis_nvic.o
                 
                mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/system_LPC17xx.o
                 
                mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/startup_LPC17xx.o
                 
                mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/retarget.o
                 
                mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/mbed.ar
  group libCoap
    ../../../../git/nsdl-c/libCoap/src/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
  group libNsdl
    ../../../../git/nsdl-c/libNsdl/src/: sn_grs.c sn_nsdl.c
