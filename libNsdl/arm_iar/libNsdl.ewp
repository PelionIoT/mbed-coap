# IAR project libNsdl.ewp, settings and files
configuration Aclara_MQX (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: VERSION="(shell git describe --tags --long --dirty --always)"
  ICCARM.CCIncludePath2: ../src/include; ../../include; ../../libCoap/src/include; ../../../libService/libService
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  postbuild: aclara_lib_copy.bat $PROJ_DIR$
  ILINK.IlinkOutputFile: libNsdl.out
configuration cortex_M4 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REG_TEMPLATE
  ICCARM.CCIncludePath2: ../src/Include; ../../libCoap/src/include; ../../../libService/libService
configuration cortex_M3 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REG_TEMPLATE
  ICCARM.CCIncludePath2: as above
configuration cortex_M0 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REG_TEMPLATE
  ICCARM.CCIncludePath2: as above
  group (top)
    ../src/: sn_grs.c sn_nsdl.c
