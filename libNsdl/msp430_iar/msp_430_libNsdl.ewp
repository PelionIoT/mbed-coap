# IAR project msp_430_libNsdl.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlff.h
  General.OGChipSelectMenu: CC430F5133 CC430F5133
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: REG_TEMPLATE
  ICC430.newCCIncludePaths: ..\src\Include; ..\..\libCoap\src\include; ..\..\..\libService\include
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsff.h
  General.OGChipSelectMenu: MSP430F5359 MSP430F5359
  General.GStackSize2: 160
  General.GHeapSize2: 160
  ICC430.newCCIncludePaths: ..\src\Include; ..\..\include; ..\..\..\libService\include; ..\..\libCoap\src\include
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5359.xcl
  group (top)
    ../src/: sn_grs.c sn_nsdl.c
