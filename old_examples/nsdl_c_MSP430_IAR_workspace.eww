<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\examples\connected-home_nanostack\connected-home_nanostack_msp_430.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\examples\lighting_nanostack_full\lighting_nanostack_full_msp_430.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\examples\lighting_nanostack\lighting_nanostack_msp_430.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libCoap\msp430_iar\msp_430_libCoap.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libNsdl\msp430_iar\msp_430_libNsdl.ewp</path>
  </project>
  <batchBuild/>
</workspace>


