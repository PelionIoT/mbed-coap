# IAR project AT256RFR2_libCoap.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-5s-ec_mul-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: ..\src\include; ..\src\x86_include
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCOptLevel: 3
  group (top)
    ../src/: sn_coap_builder_ietf_draft_09.c sn_coap_header_validity_check_ietf_draft_09.c sn_coap_parser_ietf_draft_09.c sn_coap_protocol_ietf_draft_09.c sn_linked_list.c
