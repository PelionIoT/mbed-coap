# Keil uVision project libCoap.uvproj, settings and files
target CortexM3 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: libCoapCortexM3 (library)
  c flags: Optim=1
  c define: REAL_EMBEDDED
  c misc: --c99
  c include: ..\src\include;..\..\..\libService\include
  group src
    ../src/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
