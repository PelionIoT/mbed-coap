# IAR project libCoap.ewp, settings and files
configuration Aclara_MQX (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: REAL_EMBEDDED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../src/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  postbuild: aclara_lib_copy.bat $PROJ_DIR$
  ILINK.IlinkOutputFile: libCoap.out
configuration cortex_M4 (ARM, debug)
  as the first configuration, except:
configuration cortex_M3 (ARM, debug)
  as the first configuration, except:
configuration cortex_M0 (ARM, debug)
  as the first configuration, except:
  group (top)
    ../src/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c sn_linked_list.c
