# IAR project atxmega256_libCoap.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-5s-xmega-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.newCCIncludePaths: ..\src\include
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
configuration ATxmega256_release (AVR, debug)
  as the first configuration, except:
  group (top)
    ../src/: sn_coap_builder_ietf_draft_12.c sn_coap_header_validity_check_ietf_draft_12.c sn_coap_parser_ietf_draft_12.c sn_coap_protocol_ietf_draft_12.c sn_linked_list.c
